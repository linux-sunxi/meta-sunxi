COMPATIBLE_MACHINE:sunxi = "(sun50i|sun50i-h616|sun50i-h6)"

TFA_PLATFORM:sun50i = "sun50i_a64"
TFA_PLATFORM:sun50i-h6 = "sun50i_h6"
TFA_PLATFORM:sun50i-h616 = "sun50i_h616"

TFA_BUILD_TARGET:sunxi = "bl31"
