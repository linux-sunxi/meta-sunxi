PACKAGECONFIG:class-target = "opengl x11 gallium"
