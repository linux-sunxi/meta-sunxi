PACKAGECONFIG[dri3] = "-Ddri3=true,-Ddri3=false,libxshmfence"
