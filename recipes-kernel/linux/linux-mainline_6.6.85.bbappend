
SRC_URI:append:orange-pi-one-plus = " file://axp20x.cfg"
SRC_URI:append:orange-pi-one-plus = " file://patches/0001-dts-allwinner-Orangepi-one-plus-Fixed-pmic-error.patch"

